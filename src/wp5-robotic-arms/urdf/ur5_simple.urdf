Commit message: add config for tasks

File: src/wp5-robotic-arms/urdf/ur5_simple.urdf (robot description, URDF)
Before this commit: robot ur5_robot, 11 links, 10 joints
Joints:
- joint base_link-base_link_inertia: origin xyz=0.22 0 0.28 rpy=0 0 1.57 -> xyz=0 0 0 rpy=0 0 0
